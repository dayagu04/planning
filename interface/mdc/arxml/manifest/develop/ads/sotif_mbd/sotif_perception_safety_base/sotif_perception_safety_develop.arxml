<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="6ce15a5d-0ace-4a3b-8ed4-b16a95a4a04f">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7e86b775-a9fb-4a7c-ad89-c95380ced069">
          <SHORT-NAME>Sotif</SHORT-NAME>
          <SHORT-NAME-PATTERN></SHORT-NAME-PATTERN>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="ccfeffd8-5a3c-4303-9bde-a922e19941c5">
              <SHORT-NAME>PerceptionSafety</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="1d944777-6a6f-45c1-ac68-f4f2d8a539ed">
                  <SHORT-NAME>Execution</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="43197fd5-682e-4a65-931d-0695a264b0bb">
                  <SHORT-NAME>SwComponent</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
