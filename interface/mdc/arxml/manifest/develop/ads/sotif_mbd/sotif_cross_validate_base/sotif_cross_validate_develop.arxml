<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="3b59c3db-f9ac-43ed-add4-9a60b0e19e1f">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="101b0a0f-62a2-40bb-ae75-40c4e8df8f53">
          <SHORT-NAME>Sotif</SHORT-NAME>
          <SHORT-NAME-PATTERN></SHORT-NAME-PATTERN>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="3d5c7316-addb-49e4-abcc-1cd43fe7cf1b">
              <SHORT-NAME>CrossValidate</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="5dd2267c-4249-47d8-8f98-18fb97edf9f7">
                  <SHORT-NAME>Execution</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="ffd4a47e-5013-4a19-b8f6-9b90361f0394">
                  <SHORT-NAME>SwComponent</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
