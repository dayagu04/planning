<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="9965f842-8d0b-4e8c-bc78-1c4aa58cc691">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="136a80a1-d4b0-48e0-a36d-32e171e0b1a7">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <SHORT-NAME-PATTERN></SHORT-NAME-PATTERN>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="c8c4195a-bd2a-4cdf-b28b-8096de4cb1e8">
              <SHORT-NAME>LidarDetectionApplication</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="5756835b-177e-4c22-8308-a5773d71bd6d">
                  <SHORT-NAME>Execution</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="54dff9d2-e651-4f13-9a22-d5e95ee6aa06">
                  <SHORT-NAME>SwComponent</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
