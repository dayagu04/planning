<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="9a3ddad4-8501-4786-9518-2a8e25341039">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="9d1ce5ff-8486-4c8e-85a9-9df99703b6b7">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <SHORT-NAME-PATTERN></SHORT-NAME-PATTERN>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="dcaa010a-039d-4339-a71e-5c905dedfbb0">
              <SHORT-NAME>TrafficLightDetectionApplication</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="761de0e9-58fb-48eb-af5c-40c6c6d7c23f">
                  <SHORT-NAME>Execution</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="a8c748b3-6d0d-4a51-bf35-a04c0cdab603">
                  <SHORT-NAME>SwComponent</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
