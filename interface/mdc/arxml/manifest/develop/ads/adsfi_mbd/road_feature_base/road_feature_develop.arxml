<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="b3a98c0a-057f-4cea-a56c-12c0deff5e24">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="211a74e1-3902-4e74-8fa7-810c67f8f7d6">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <SHORT-NAME-PATTERN></SHORT-NAME-PATTERN>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="dc1afc41-e00a-42cb-a0df-e09a76380bac">
              <SHORT-NAME>RoadFeature</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="e1032b7c-0a80-4665-866e-74726d1297e1">
                  <SHORT-NAME>Execution</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0d4b568a-bab9-4ad7-8f74-86a965c3c402">
                  <SHORT-NAME>SwComponent</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
