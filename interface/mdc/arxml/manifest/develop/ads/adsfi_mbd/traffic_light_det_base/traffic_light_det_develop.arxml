<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="6e1454d5-5ef8-4fb5-9436-49a22b5ef107">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="a3f7966d-9c38-4093-9db7-d094e8fc014b">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <SHORT-NAME-PATTERN></SHORT-NAME-PATTERN>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="4dc1c5b7-0edc-454d-aa03-f48b1cedc39f">
              <SHORT-NAME>TrafficLightDet</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="da8b8de5-85e9-4e7c-904e-66cc1967be20">
                  <SHORT-NAME>Execution</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="8cee241a-685b-46c0-877c-d255f3dbac0a">
                  <SHORT-NAME>SwComponent</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
