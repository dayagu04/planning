<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="ba959ed8-408c-47f0-a512-0511f5e039ce">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="3a50b815-c8b5-4f6f-87fb-2400b1fe21fd">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="9cf3047e-e9f7-4d58-baf9-08af24a8acff">
              <SHORT-NAME>NavigationApplication</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="962c6131-e663-48df-9611-b23d30623b6b">
                  <SHORT-NAME>Execution</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="793b1ef4-db05-4528-9fc2-2937f37bf5d5">
                  <SHORT-NAME>SwComponent</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
