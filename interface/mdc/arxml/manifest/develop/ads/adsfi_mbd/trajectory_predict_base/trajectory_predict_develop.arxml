<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="0aa7e2e6-5962-4580-82ac-98d32c3f44bb">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="170ee769-57b6-4673-88e0-f2225ad0aa26">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <SHORT-NAME-PATTERN></SHORT-NAME-PATTERN>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="f482e2be-a12b-4c5d-a6ff-9a1830a775a3">
              <SHORT-NAME>TrajectoryPredict</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="11cb7470-cd23-4697-b5b0-ccad73ca680e">
                  <SHORT-NAME>Execution</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="f5bac366-5812-4285-b6ce-977b655ac1d7">
                  <SHORT-NAME>SwComponent</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
