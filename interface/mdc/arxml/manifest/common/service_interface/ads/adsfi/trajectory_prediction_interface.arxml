<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="eb1e80bd-de92-43a4-97dc-895bcdb842d7">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="53b8ff7e-b204-4674-a291-23ab66bc6cb5">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="da211b9c-5152-4343-b311-136f2331dbdb">
              <SHORT-NAME>TrajetoryPredictionMsgDataType</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="c6772a3a-36c0-4ff5-b40a-c4c28e0b558a">
              <SHORT-NAME>TrajetoryPredictionServiceInterface</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
