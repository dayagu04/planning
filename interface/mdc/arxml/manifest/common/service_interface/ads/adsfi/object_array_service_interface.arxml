<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="4aec60c3-6b08-4858-b906-67b5108e5275">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="9011aaa6-d228-401b-8289-857a34929149">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="696c35f3-70e6-46b5-9a1e-d6b089eb144f">
              <SHORT-NAME>ObjectArrayMsgDataType</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="3afa1010-cfb9-4d4d-a412-ae7da232d5c6">
              <SHORT-NAME>ObjectArrayServiceInterface</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
