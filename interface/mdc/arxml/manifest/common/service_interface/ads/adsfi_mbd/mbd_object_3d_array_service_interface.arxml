<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="dfd87ae8-52c9-4d9a-a16e-8919e8fb6317">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="0b45417d-3ff2-4948-a304-bcfd56a29998">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="6accf36a-1e9d-481b-a33b-02f4565f2083">
              <SHORT-NAME>Object3dArrayMsgDataType</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="40acb898-49c2-4667-84cb-993c338d5097">
              <SHORT-NAME>Object3dArrayServiceInterface</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
