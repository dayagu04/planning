<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="3f82ee86-78ba-4dc8-8872-0130f8807197">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="d5a78310-31ff-482c-ad04-d27b9f6ef6a0">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="c1fe0c31-d78d-4a47-8336-1891087501b8">
              <SHORT-NAME>LaneLineArrayMsgDataType</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="5bbe5786-df3f-4cb5-acaa-e37fa085fd0f">
              <SHORT-NAME>LaneLineArrayServiceInterface</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
