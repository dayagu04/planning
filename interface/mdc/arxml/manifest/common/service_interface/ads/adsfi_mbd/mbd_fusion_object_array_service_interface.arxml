<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="635b218a-21b2-47d1-9eb8-b37c3734e71d">
      <SHORT-NAME>HuaweiMDC</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="398f8970-9828-47f2-a44b-8af4c76056bb">
          <SHORT-NAME>FunctionalSoftware</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="dd6d357b-917a-4d44-867c-ac4ae4f5cc59">
              <SHORT-NAME>FusionObjectArrayMsgDataType</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8fe9d78d-96fb-4f32-b1c0-cc49f1e5841d">
              <SHORT-NAME>FusionObjectArrayServiceInterface</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
